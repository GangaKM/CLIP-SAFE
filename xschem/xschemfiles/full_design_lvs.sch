v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -8570 16420 -8570 16460 {
lab=Vbias}
N -8630 16490 -8610 16490 {
lab=Vbias}
N -8630 16440 -8630 16490 {
lab=Vbias}
N -8630 16440 -8570 16440 {
lab=Vbias}
N -8570 16520 -8570 16560 {
lab=gnd}
N -8570 16490 -8570 16530 {
lab=gnd}
N -8970 16300 -8970 16320 {
lab=Vdd}
N -8790 16300 -8790 16320 {
lab=Vdd}
N -8930 16350 -8830 16350 {
lab=Vbp}
N -8970 16300 -8790 16300 {
lab=Vdd}
N -9010 16280 -9010 16300 {
lab=Vdd}
N -9010 16300 -8950 16300 {
lab=Vdd}
N -8800 16280 -8800 16300 {
lab=Vdd}
N -8970 16250 -8970 16300 {
lab=Vdd}
N -8840 16250 -8840 16300 {
lab=Vdd}
N -9010 16220 -8930 16220 {
lab=Vdd}
N -8930 16220 -8930 16300 {
lab=Vdd}
N -8880 16220 -8800 16220 {
lab=Vdd}
N -8880 16220 -8880 16300 {
lab=Vdd}
N -8970 16310 -8970 16350 {
lab=Vdd}
N -8790 16300 -8790 16350 {
lab=Vdd}
N -9010 16250 -9010 16300 {
lab=Vdd}
N -8800 16250 -8800 16290 {
lab=Vdd}
N -8970 16380 -8970 16410 {
lab=vin1}
N -8790 16380 -8790 16410 {
lab=vin2}
N -8900 16450 -8900 16490 {
lab=Vs}
N -8960 16520 -8940 16520 {
lab=Vbias}
N -8960 16470 -8960 16520 {
lab=Vbias}
N -8900 16550 -8900 16590 {
lab=gnd}
N -8900 16520 -8900 16560 {
lab=gnd}
N -8900 16290 -8880 16290 {
lab=Vdd}
N -8750 15780 -8750 15860 {
lab=#net1}
N -8570 15780 -8570 15860 {
lab=Vbp}
N -8750 15700 -8750 15720 {
lab=Vdd}
N -8570 15700 -8570 15720 {
lab=Vdd}
N -8750 15920 -8750 15940 {
lab=#net2}
N -8750 15940 -8570 15940 {
lab=#net2}
N -8570 15920 -8570 15940 {
lab=#net2}
N -8710 15750 -8610 15750 {
lab=#net1}
N -8670 15750 -8670 15820 {
lab=#net1}
N -8750 15820 -8670 15820 {
lab=#net1}
N -9150 15680 -9150 15710 {
lab=Vdd}
N -9150 15680 -8960 15680 {
lab=Vdd}
N -8960 15680 -8960 15710 {
lab=Vdd}
N -9150 15770 -9150 15850 {
lab=Vcm_det1}
N -8960 15770 -8960 15850 {
lab=Vcm_det1}
N -9210 15740 -9190 15740 {
lab=vin1}
N -9210 15740 -9210 15880 {
lab=vin1}
N -9210 15880 -9190 15880 {
lab=vin1}
N -8920 15740 -8900 15740 {
lab=vin2}
N -8900 15740 -8900 15880 {
lab=vin2}
N -8920 15880 -8900 15880 {
lab=vin2}
N -8350 15710 -8350 15740 {
lab=Vdd}
N -8350 15710 -8160 15710 {
lab=Vdd}
N -8160 15710 -8160 15740 {
lab=Vdd}
N -8350 15800 -8350 15880 {
lab=Vcm1}
N -8160 15800 -8160 15880 {
lab=Vcm1}
N -8350 15940 -8350 15970 {
lab=gnd}
N -8160 15940 -8160 15970 {
lab=gnd}
N -8410 15770 -8390 15770 {
lab=Vc1+}
N -8410 15770 -8410 15910 {
lab=Vc1+}
N -8410 15910 -8390 15910 {
lab=Vc1+}
N -8120 15770 -8100 15770 {
lab=Vc1+}
N -8100 15770 -8100 15910 {
lab=Vc1+}
N -8120 15910 -8100 15910 {
lab=Vc1+}
N -8660 15940 -8660 15970 {
lab=#net2}
N -8660 16030 -8660 16060 {
lab=gnd}
N -9150 15810 -8960 15810 {
lab=Vcm_det1}
N -8350 15840 -8160 15840 {
lab=Vcm1}
N -8820 15890 -8790 15890 {
lab=Vcm_det1}
N -8530 15890 -8500 15890 {
lab=Vcm1}
N -8750 15700 -8570 15700 {
lab=Vdd}
N -8350 15970 -8160 15970 {
lab=gnd}
N -8820 16040 -8820 16060 {
lab=gnd}
N -8820 16060 -8520 16060 {
lab=gnd}
N -8520 16030 -8520 16060 {
lab=gnd}
N -8860 16010 -8860 16060 {
lab=gnd}
N -8860 16060 -8820 16060 {
lab=gnd}
N -8820 15980 -8780 15980 {
lab=gnd}
N -8780 15980 -8780 16060 {
lab=gnd}
N -8480 16000 -8480 16060 {
lab=gnd}
N -8520 16060 -8480 16060 {
lab=gnd}
N -8570 15970 -8520 15970 {
lab=gnd}
N -8570 15970 -8570 16060 {
lab=gnd}
N -8790 15680 -8790 15700 {
lab=Vdd}
N -8790 15700 -8730 15700 {
lab=Vdd}
N -8580 15680 -8580 15700 {
lab=Vdd}
N -8750 15650 -8750 15700 {
lab=Vdd}
N -8620 15650 -8620 15700 {
lab=Vdd}
N -8790 15620 -8710 15620 {
lab=Vdd}
N -8710 15620 -8710 15700 {
lab=Vdd}
N -8660 15620 -8580 15620 {
lab=Vdd}
N -8660 15620 -8660 15700 {
lab=Vdd}
N -9150 15910 -9150 15940 {
lab=gnd}
N -9150 15940 -8960 15940 {
lab=gnd}
N -8960 15910 -8960 15940 {
lab=gnd}
N -8750 15710 -8750 15750 {
lab=Vdd}
N -8570 15700 -8570 15750 {
lab=Vdd}
N -8790 15650 -8790 15700 {
lab=Vdd}
N -8580 15650 -8580 15690 {
lab=Vdd}
N -8820 16010 -8820 16050 {
lab=gnd}
N -8520 16000 -8520 16040 {
lab=gnd}
N -8660 16000 -8660 16040 {
lab=gnd}
N -9150 15740 -9100 15740 {
lab=gnd}
N -9030 15740 -8960 15740 {
lab=gnd}
N -9100 15740 -9030 15740 {
lab=gnd}
N -9150 15880 -8960 15880 {
lab=Vdd}
N -8350 15770 -8160 15770 {
lab=gnd}
N -8350 15910 -8160 15910 {
lab=Vdd}
N -8750 15890 -8570 15890 {
lab=gnd}
N -8730 16000 -8700 16000 {
lab=Vbias}
N -7950 16450 -7950 16470 {
lab=#net3}
N -7950 16470 -7770 16470 {
lab=#net3}
N -7620 16450 -7620 16470 {
lab=#net3}
N -7950 16180 -7950 16200 {
lab=Vdd}
N -7950 16180 -7770 16180 {
lab=Vdd}
N -7620 16180 -7620 16200 {
lab=Vdd}
N -7770 16180 -7620 16180 {
lab=Vdd}
N -7770 16470 -7620 16470 {
lab=#net3}
N -7950 16330 -7820 16330 {
lab=vo1}
N -7760 16330 -7620 16330 {
lab=vo2}
N -8110 16230 -7990 16230 {
lab=Vbn}
N -7580 16230 -7470 16230 {
lab=Vbn}
N -8020 16420 -7990 16420 {
lab=vin1}
N -7580 16420 -7540 16420 {
lab=vin2}
N -7950 16320 -7950 16390 {
lab=vo1}
N -7620 16320 -7620 16390 {
lab=vo2}
N -7620 16250 -7620 16320 {
lab=vo2}
N -7950 16260 -7950 16320 {
lab=vo1}
N -7790 16470 -7790 16530 {
lab=#net3}
N -8110 16430 -8110 16470 {
lab=gnd}
N -7440 16430 -7440 16470 {
lab=gnd}
N -8150 16400 -8150 16470 {
lab=gnd}
N -8150 16470 -8110 16470 {
lab=gnd}
N -8110 16370 -8090 16370 {
lab=gnd}
N -8090 16370 -8090 16470 {
lab=gnd}
N -8110 16400 -8110 16450 {
lab=gnd}
N -7460 16370 -7440 16370 {
lab=gnd}
N -7460 16370 -7460 16470 {
lab=gnd}
N -7440 16400 -7440 16450 {
lab=gnd}
N -7400 16400 -7400 16470 {
lab=gnd}
N -7440 16470 -7400 16470 {
lab=gnd}
N -7960 16160 -7960 16180 {
lab=Vdd}
N -7960 16180 -7950 16180 {
lab=Vdd}
N -7630 16160 -7630 16180 {
lab=Vdd}
N -7960 16100 -7890 16100 {
lab=Vdd}
N -7890 16100 -7890 16180 {
lab=Vdd}
N -7660 16100 -7630 16100 {
lab=Vdd}
N -7660 16100 -7660 16180 {
lab=Vdd}
N -7960 16130 -7940 16130 {
lab=Vdd}
N -7940 16130 -7940 16180 {
lab=Vdd}
N -7650 16130 -7630 16130 {
lab=Vdd}
N -7650 16130 -7650 16180 {
lab=Vdd}
N -7590 16130 -7590 16180 {
lab=Vdd}
N -7620 16180 -7590 16180 {
lab=Vdd}
N -8000 16130 -8000 16180 {
lab=Vdd}
N -8000 16180 -7960 16180 {
lab=Vdd}
N -7950 16190 -7950 16230 {
lab=Vdd}
N -7620 16190 -7620 16230 {
lab=Vdd}
N -7890 16830 -7890 16910 {
lab=#net4}
N -7710 16830 -7710 16910 {
lab=Vbn}
N -7890 16750 -7890 16770 {
lab=Vdd}
N -7710 16750 -7710 16770 {
lab=Vdd}
N -7890 16970 -7890 16990 {
lab=#net5}
N -7890 16990 -7710 16990 {
lab=#net5}
N -7710 16970 -7710 16990 {
lab=#net5}
N -7850 16800 -7750 16800 {
lab=#net4}
N -7810 16800 -7810 16870 {
lab=#net4}
N -7890 16870 -7810 16870 {
lab=#net4}
N -8290 16730 -8290 16760 {
lab=Vdd}
N -8290 16730 -8100 16730 {
lab=Vdd}
N -8100 16730 -8100 16760 {
lab=Vdd}
N -8290 16820 -8290 16900 {
lab=Vcm_det}
N -8100 16820 -8100 16900 {
lab=Vcm_det}
N -8350 16790 -8330 16790 {
lab=vo1}
N -8350 16790 -8350 16930 {
lab=vo1}
N -8350 16930 -8330 16930 {
lab=vo1}
N -8060 16790 -8040 16790 {
lab=vo2}
N -8040 16790 -8040 16930 {
lab=vo2}
N -8060 16930 -8040 16930 {
lab=vo2}
N -7490 16760 -7490 16790 {
lab=Vdd}
N -7490 16760 -7300 16760 {
lab=Vdd}
N -7300 16760 -7300 16790 {
lab=Vdd}
N -7490 16850 -7490 16930 {
lab=Vcm}
N -7300 16850 -7300 16930 {
lab=Vcm}
N -7490 16990 -7490 17020 {
lab=gnd}
N -7300 16990 -7300 17020 {
lab=gnd}
N -7550 16820 -7530 16820 {
lab=Vc1+}
N -7550 16820 -7550 16960 {
lab=Vc1+}
N -7550 16960 -7530 16960 {
lab=Vc1+}
N -7260 16820 -7240 16820 {
lab=Vc1+}
N -7240 16820 -7240 16960 {
lab=Vc1+}
N -7260 16960 -7240 16960 {
lab=Vc1+}
N -7800 16990 -7800 17020 {
lab=#net5}
N -7800 17080 -7800 17110 {
lab=gnd}
N -8290 16860 -8100 16860 {
lab=Vcm_det}
N -7490 16890 -7300 16890 {
lab=Vcm}
N -7960 16940 -7930 16940 {
lab=Vcm_det}
N -7670 16940 -7640 16940 {
lab=Vcm}
N -7890 16750 -7710 16750 {
lab=Vdd}
N -7490 17020 -7300 17020 {
lab=gnd}
N -7960 17090 -7960 17110 {
lab=gnd}
N -7960 17110 -7660 17110 {
lab=gnd}
N -7660 17080 -7660 17110 {
lab=gnd}
N -8000 17060 -8000 17110 {
lab=gnd}
N -8000 17110 -7960 17110 {
lab=gnd}
N -7960 17030 -7920 17030 {
lab=gnd}
N -7920 17030 -7920 17110 {
lab=gnd}
N -7620 17050 -7620 17110 {
lab=gnd}
N -7660 17110 -7620 17110 {
lab=gnd}
N -7710 17020 -7660 17020 {
lab=gnd}
N -7710 17020 -7710 17110 {
lab=gnd}
N -7930 16730 -7930 16750 {
lab=Vdd}
N -7930 16750 -7870 16750 {
lab=Vdd}
N -7720 16730 -7720 16750 {
lab=Vdd}
N -7890 16700 -7890 16750 {
lab=Vdd}
N -7760 16700 -7760 16750 {
lab=Vdd}
N -7930 16670 -7850 16670 {
lab=Vdd}
N -7850 16670 -7850 16750 {
lab=Vdd}
N -7800 16670 -7720 16670 {
lab=Vdd}
N -7800 16670 -7800 16750 {
lab=Vdd}
N -8290 16960 -8290 16990 {
lab=gnd}
N -8290 16990 -8100 16990 {
lab=gnd}
N -8100 16960 -8100 16990 {
lab=gnd}
N -7890 16760 -7890 16800 {
lab=Vdd}
N -7710 16750 -7710 16800 {
lab=Vdd}
N -7930 16700 -7930 16750 {
lab=Vdd}
N -7720 16700 -7720 16740 {
lab=Vdd}
N -7960 17060 -7960 17100 {
lab=gnd}
N -7660 17050 -7660 17090 {
lab=gnd}
N -7800 17050 -7800 17090 {
lab=gnd}
N -8290 16790 -8240 16790 {
lab=gnd}
N -8170 16790 -8100 16790 {
lab=gnd}
N -8240 16790 -8170 16790 {
lab=gnd}
N -8290 16930 -8100 16930 {
lab=Vdd}
N -7490 16820 -7300 16820 {
lab=gnd}
N -7490 16960 -7300 16960 {
lab=Vdd}
N -7890 16940 -7710 16940 {
lab=gnd}
N -7870 17050 -7840 17050 {
lab=Vbias1}
N -7950 16420 -7620 16420 {
lab=gnd}
N -7790 16590 -7670 16590 {
lab=gnd}
N -7790 16560 -7760 16560 {
lab=gnd}
N -7760 16560 -7760 16590 {
lab=gnd}
N -7890 16560 -7830 16560 {
lab=Vbias1}
N -8110 16470 -8090 16470 {
lab=gnd}
N -7460 16470 -7440 16470 {
lab=gnd}
N -8880 16750 -8850 16750 {
lab=gnd}
N -8850 16750 -8850 16810 {
lab=gnd}
N -8880 16810 -8850 16810 {
lab=gnd}
N -8880 16780 -8850 16780 {
lab=gnd}
N -8950 16810 -8500 16810 {
lab=gnd}
N -8920 16750 -8920 16780 {
lab=Vdd}
N -8760 16750 -8760 16780 {
lab=Vdd}
N -8920 16720 -8920 16750 {
lab=Vdd}
N -8920 16720 -8500 16720 {
lab=Vdd}
N -8760 16720 -8760 16750 {
lab=Vdd}
N -8720 16750 -8680 16750 {
lab=gnd}
N -8680 16750 -8680 16810 {
lab=gnd}
N -8720 16780 -8680 16780 {
lab=gnd}
N -8610 16720 -8610 16780 {
lab=Vdd}
N -8570 16780 -8530 16780 {
lab=gnd}
N -8530 16780 -8530 16810 {
lab=gnd}
N -8570 16750 -8530 16750 {
lab=gnd}
N -8530 16750 -8530 16780 {
lab=gnd}
N -8500 16720 -8380 16720 {
lab=Vdd}
N -8500 16810 -8390 16810 {
lab=gnd}
N -8470 16720 -8470 16780 {
lab=Vdd}
N -8430 16750 -8400 16750 {
lab=gnd}
N -8400 16750 -8400 16810 {
lab=gnd}
N -8430 16780 -8400 16780 {
lab=gnd}
N -9000 16940 -8970 16940 {
lab=Vdd}
N -8970 16940 -8970 17000 {
lab=Vdd}
N -9000 17000 -8970 17000 {
lab=Vdd}
N -9000 16970 -8970 16970 {
lab=Vdd}
N -9070 17000 -8620 17000 {
lab=Vdd}
N -9040 16940 -9040 16970 {
lab=gnd}
N -8880 16940 -8880 16970 {
lab=gnd}
N -9040 16910 -9040 16940 {
lab=gnd}
N -9040 16910 -8620 16910 {
lab=gnd}
N -8880 16910 -8880 16940 {
lab=gnd}
N -8840 16940 -8800 16940 {
lab=Vdd}
N -8800 16940 -8800 17000 {
lab=Vdd}
N -8840 16970 -8800 16970 {
lab=Vdd}
N -8730 16910 -8730 16970 {
lab=gnd}
N -8690 16970 -8650 16970 {
lab=Vdd}
N -8650 16970 -8650 17000 {
lab=Vdd}
N -8690 16940 -8650 16940 {
lab=Vdd}
N -8650 16940 -8650 16970 {
lab=Vdd}
N -8620 16910 -8500 16910 {
lab=gnd}
N -8620 17000 -8510 17000 {
lab=Vdd}
N -8590 16910 -8590 16970 {
lab=gnd}
N -8550 16940 -8520 16940 {
lab=Vdd}
N -8520 16940 -8520 17000 {
lab=Vdd}
N -8550 16970 -8520 16970 {
lab=Vdd}
N -8500 16910 -8400 16910 {
lab=gnd}
N -8510 17000 -8360 17000 {
lab=Vdd}
N -8410 16940 -8380 16940 {
lab=Vdd}
N -8380 16940 -8380 17000 {
lab=Vdd}
N -8410 16970 -8380 16970 {
lab=Vdd}
N -8450 16910 -8450 16970 {
lab=gnd}
N -9170 16910 -9040 16910 {
lab=gnd}
N -9180 17000 -9070 17000 {
lab=Vdd}
N -9170 16910 -9170 16970 {
lab=gnd}
N -9130 16940 -9100 16940 {
lab=Vdd}
N -9100 16940 -9100 17000 {
lab=Vdd}
N -9130 16970 -9100 16970 {
lab=Vdd}
N -8850 17130 -8820 17130 {
lab=gnd}
N -8820 17130 -8820 17190 {
lab=gnd}
N -8850 17190 -8820 17190 {
lab=gnd}
N -8850 17160 -8820 17160 {
lab=gnd}
N -8890 17130 -8890 17160 {
lab=Vbias1}
N -8890 17100 -8890 17130 {
lab=Vbias1}
N -8890 17100 -8810 17100 {
lab=Vbias1}
N -8540 17160 -8510 17160 {
lab=Vbias1}
N -8540 17220 -8510 17220 {
lab=gnd}
N -8580 17160 -8580 17190 {
lab=Vbias1}
N -8580 17130 -8580 17160 {
lab=Vbias1}
N -8580 17130 -8500 17130 {
lab=Vbias1}
N -8540 17190 -8520 17190 {
lab=gnd}
N -8520 17190 -8520 17220 {
lab=gnd}
N -8510 17130 -8510 17160 {
lab=Vbias1}
N -8500 17130 -8460 17130 {
lab=Vbias1}
N -6270 15670 -6270 15790 {
lab=Vo+}
N -6100 15670 -6100 15780 {
lab=Vo-}
N -6100 15780 -6100 15790 {
lab=Vo-}
N -6270 15590 -6270 15610 {
lab=Vdd}
N -6270 15590 -6100 15590 {
lab=Vdd}
N -6100 15590 -6100 15610 {
lab=Vdd}
N -6230 15640 -6220 15640 {
lab=Vo-}
N -6220 15640 -6220 15820 {
lab=Vo-}
N -6230 15820 -6220 15820 {
lab=Vo-}
N -6150 15640 -6140 15640 {
lab=Vo+}
N -6150 15640 -6150 15820 {
lab=Vo+}
N -6150 15820 -6140 15820 {
lab=Vo+}
N -6420 15590 -6270 15590 {
lab=Vdd}
N -6420 15590 -6420 15610 {
lab=Vdd}
N -6100 15590 -5940 15590 {
lab=Vdd}
N -5940 15590 -5940 15610 {
lab=Vdd}
N -6420 15670 -6420 15690 {
lab=Vo+}
N -6420 15690 -6270 15690 {
lab=Vo+}
N -5940 15670 -5940 15690 {
lab=Vo-}
N -6100 15690 -5940 15690 {
lab=Vo-}
N -6270 15680 -6150 15680 {
lab=Vo+}
N -6220 15700 -6100 15700 {
lab=Vo-}
N -6270 15850 -6270 15920 {
lab=#net6}
N -6100 15850 -6100 15920 {
lab=#net7}
N -6270 15980 -6270 16020 {
lab=#net8}
N -6270 16020 -6100 16020 {
lab=#net8}
N -6100 15970 -6100 16020 {
lab=#net8}
N -5940 15980 -5940 16020 {
lab=#net8}
N -6100 16020 -5940 16020 {
lab=#net8}
N -5940 15900 -5940 15920 {
lab=#net7}
N -6100 15900 -5940 15900 {
lab=#net7}
N -6400 15980 -6400 16020 {
lab=#net8}
N -6400 16020 -6270 16020 {
lab=#net8}
N -6400 15890 -6400 15920 {
lab=#net6}
N -6400 15890 -6270 15890 {
lab=#net6}
N -6160 16020 -6160 16050 {
lab=#net8}
N -6250 16080 -6200 16080 {
lab=clk}
N -6160 16110 -6160 16150 {
lab=GND}
N -6270 15880 -6230 15880 {
lab=#net6}
N -6170 15880 -6100 15880 {
lab=#net7}
N -6480 15950 -6440 15950 {
lab=Vc-}
N -6340 15950 -6310 15950 {
lab=vo1}
N -6060 15950 -6030 15950 {
lab=vo2}
N -5900 15950 -5870 15950 {
lab=Vc+}
N -5900 15640 -5860 15640 {
lab=clk}
N -6500 15640 -6460 15640 {
lab=clk}
N -6270 15950 -6100 15950 {
lab=GND}
N -5970 15950 -5940 15950 {
lab=GND}
N -6400 15950 -6370 15950 {
lab=GND}
N -6420 15620 -6420 15640 {
lab=Vdd}
N -6270 15620 -6270 15640 {
lab=Vdd}
N -6100 15610 -6100 15630 {
lab=Vdd}
N -6100 15620 -6100 15640 {
lab=Vdd}
N -5940 15600 -5940 15640 {
lab=Vdd}
N -6270 15600 -6270 15640 {
lab=Vdd}
N -6420 15590 -6420 15640 {
lab=Vdd}
N -6100 15820 -6020 15820 {
lab=GND}
N -6350 15820 -6270 15820 {
lab=GND}
N -6200 15810 -6200 15880 {
lab=Vdd}
N -6200 15920 -6150 15920 {
lab=clk}
N -6160 16080 -6130 16080 {
lab=GND}
N -6130 16080 -6130 16130 {
lab=GND}
N -6160 16130 -6130 16130 {
lab=GND}
N -5460 15600 -5460 15620 {
lab=Vdd}
N -5460 15600 -5290 15600 {
lab=Vdd}
N -5290 15600 -5290 15620 {
lab=Vdd}
N -5420 15650 -5410 15650 {
lab=Vo1+}
N -5340 15650 -5330 15650 {
lab=Vo1-}
N -5610 15600 -5460 15600 {
lab=Vdd}
N -5610 15600 -5610 15620 {
lab=Vdd}
N -5290 15600 -5130 15600 {
lab=Vdd}
N -5130 15600 -5130 15620 {
lab=Vdd}
N -5610 15680 -5610 15700 {
lab=Q}
N -5130 15680 -5130 15700 {
lab=Q1}
N -5090 15650 -5050 15650 {
lab=Vo+}
N -5690 15650 -5650 15650 {
lab=Vo-}
N -5610 15630 -5610 15650 {
lab=Vdd}
N -5460 15630 -5460 15650 {
lab=Vdd}
N -5290 15620 -5290 15640 {
lab=Vdd}
N -5290 15630 -5290 15650 {
lab=Vdd}
N -5130 15610 -5130 15650 {
lab=Vdd}
N -5460 15610 -5460 15650 {
lab=Vdd}
N -5610 15600 -5610 15650 {
lab=Vdd}
N -5290 15680 -5290 15770 {
lab=#net9}
N -5460 15850 -5460 15970 {
lab=Q}
N -5290 15850 -5290 15960 {
lab=Q1}
N -5290 15960 -5290 15970 {
lab=Q1}
N -5460 15770 -5460 15790 {
lab=#net10}
N -5290 15770 -5290 15790 {
lab=#net9}
N -5420 15820 -5410 15820 {
lab=Q1}
N -5410 15820 -5410 16000 {
lab=Q1}
N -5420 16000 -5410 16000 {
lab=Q1}
N -5340 15820 -5330 15820 {
lab=Q}
N -5340 15820 -5340 16000 {
lab=Q}
N -5340 16000 -5330 16000 {
lab=Q}
N -5460 15860 -5340 15860 {
lab=Q}
N -5410 15880 -5290 15880 {
lab=Q1}
N -5290 16000 -5210 16000 {
lab=GND}
N -5460 15680 -5460 15770 {
lab=#net10}
N -5460 16140 -5460 16180 {
lab=GND}
N -5460 16180 -5290 16180 {
lab=GND}
N -5290 16130 -5290 16180 {
lab=GND}
N -5130 16140 -5130 16180 {
lab=GND}
N -5290 16180 -5130 16180 {
lab=GND}
N -5130 16060 -5130 16080 {
lab=Q1}
N -5610 16140 -5610 16180 {
lab=GND}
N -5590 16180 -5460 16180 {
lab=GND}
N -5610 16050 -5610 16080 {
lab=Q}
N -5350 16180 -5350 16210 {
lab=GND}
N -5690 16110 -5650 16110 {
lab=Vo1+}
N -5530 16110 -5500 16110 {
lab=Vo-}
N -5250 16110 -5220 16110 {
lab=Vo+}
N -5090 16110 -5060 16110 {
lab=Vo1-}
N -5460 16110 -5290 16110 {
lab=GND}
N -5160 16110 -5130 16110 {
lab=GND}
N -5610 16110 -5580 16110 {
lab=GND}
N -5460 16030 -5460 16080 {
lab=#net11}
N -5290 16030 -5290 16080 {
lab=#net12}
N -5610 15700 -5610 16050 {
lab=Q}
N -5130 15700 -5130 16050 {
lab=Q1}
N -5130 16050 -5130 16060 {
lab=Q1}
N -5610 16180 -5590 16180 {
lab=GND}
N -5350 15650 -5340 15650 {
lab=Vo1-}
N -5410 15650 -5400 15650 {
lab=Vo1+}
N -5610 15890 -5460 15890 {
lab=Q}
N -5290 15900 -5130 15900 {
lab=Q1}
N -6140 16260 -6060 16260 {
lab=Vo+}
N -6120 16500 -6040 16500 {
lab=Vo-}
N -6000 16520 -5920 16520 {
lab=Vo1-}
N -5520 15820 -5460 15820 {
lab=Vdd}
N -5520 15600 -5520 15820 {
lab=Vdd}
N -5290 15820 -5250 15820 {
lab=Vdd}
N -5250 15600 -5250 15820 {
lab=Vdd}
N -5550 16000 -5460 16000 {
lab=GND}
N -5550 16000 -5550 16180 {
lab=GND}
N -6000 16350 -6000 16370 {
lab=GND}
N -6040 16240 -6040 16320 {
lab=Vo+}
N -6060 16260 -6040 16260 {
lab=Vo+}
N -6000 16270 -6000 16290 {
lab=Vo1+}
N -6000 16280 -5880 16280 {
lab=Vo1+}
N -6000 16180 -6000 16210 {
lab=Vdd}
N -6000 16190 -6000 16240 {
lab=Vdd}
N -6000 16320 -6000 16360 {
lab=GND}
N -6040 16480 -6040 16560 {
lab=Vo-}
N -6000 16510 -6000 16530 {
lab=Vo1-}
N -6000 16600 -6000 16610 {
lab=GND}
N -6000 16590 -6000 16600 {
lab=GND}
N -6000 16560 -6000 16600 {
lab=GND}
N -6000 16430 -6000 16450 {
lab=Vdd}
N -6000 16440 -6000 16480 {
lab=Vdd}
N -6250 16870 -6250 16990 {
lab=Vo2+}
N -6080 16870 -6080 16980 {
lab=Vo2-}
N -6080 16980 -6080 16990 {
lab=Vo2-}
N -6250 16790 -6250 16810 {
lab=Vdd}
N -6250 16790 -6080 16790 {
lab=Vdd}
N -6080 16790 -6080 16810 {
lab=Vdd}
N -6210 16840 -6200 16840 {
lab=Vo2-}
N -6200 16840 -6200 17020 {
lab=Vo2-}
N -6210 17020 -6200 17020 {
lab=Vo2-}
N -6130 16840 -6120 16840 {
lab=Vo2+}
N -6130 16840 -6130 17020 {
lab=Vo2+}
N -6130 17020 -6120 17020 {
lab=Vo2+}
N -6400 16790 -6250 16790 {
lab=Vdd}
N -6400 16790 -6400 16810 {
lab=Vdd}
N -6080 16790 -5920 16790 {
lab=Vdd}
N -5920 16790 -5920 16810 {
lab=Vdd}
N -6400 16870 -6400 16890 {
lab=Vo2+}
N -6400 16890 -6250 16890 {
lab=Vo2+}
N -5920 16870 -5920 16890 {
lab=Vo2-}
N -6080 16890 -5920 16890 {
lab=Vo2-}
N -6250 16880 -6130 16880 {
lab=Vo2+}
N -6200 16900 -6080 16900 {
lab=Vo2-}
N -6250 17050 -6250 17120 {
lab=#net13}
N -6080 17050 -6080 17120 {
lab=#net14}
N -6250 17180 -6250 17220 {
lab=#net15}
N -6250 17220 -6080 17220 {
lab=#net15}
N -6080 17170 -6080 17220 {
lab=#net15}
N -5920 17180 -5920 17220 {
lab=#net15}
N -6080 17220 -5920 17220 {
lab=#net15}
N -5920 17100 -5920 17120 {
lab=#net14}
N -6080 17100 -5920 17100 {
lab=#net14}
N -6380 17180 -6380 17220 {
lab=#net15}
N -6380 17220 -6250 17220 {
lab=#net15}
N -6380 17090 -6380 17120 {
lab=#net13}
N -6380 17090 -6250 17090 {
lab=#net13}
N -6140 17220 -6140 17250 {
lab=#net15}
N -6230 17280 -6180 17280 {
lab=clk}
N -6140 17310 -6140 17350 {
lab=GND}
N -6250 17080 -6210 17080 {
lab=#net13}
N -6150 17080 -6080 17080 {
lab=#net14}
N -6460 17150 -6420 17150 {
lab=Vc+}
N -6320 17150 -6290 17150 {
lab=vo1}
N -6040 17150 -6010 17150 {
lab=vo2}
N -5880 17150 -5850 17150 {
lab=Vc-}
N -5880 16840 -5840 16840 {
lab=clk}
N -6480 16840 -6440 16840 {
lab=clk}
N -6250 17150 -6080 17150 {
lab=GND}
N -5950 17150 -5920 17150 {
lab=GND}
N -6380 17150 -6350 17150 {
lab=GND}
N -6400 16820 -6400 16840 {
lab=Vdd}
N -6250 16820 -6250 16840 {
lab=Vdd}
N -6080 16810 -6080 16830 {
lab=Vdd}
N -6080 16820 -6080 16840 {
lab=Vdd}
N -5920 16800 -5920 16840 {
lab=Vdd}
N -6250 16800 -6250 16840 {
lab=Vdd}
N -6400 16790 -6400 16840 {
lab=Vdd}
N -6080 17020 -6000 17020 {
lab=GND}
N -6330 17020 -6250 17020 {
lab=GND}
N -6180 17010 -6180 17080 {
lab=Vdd}
N -6180 17120 -6130 17120 {
lab=clk}
N -6140 17280 -6110 17280 {
lab=GND}
N -6110 17280 -6110 17330 {
lab=GND}
N -6140 17330 -6110 17330 {
lab=GND}
N -5440 16800 -5440 16820 {
lab=Vdd}
N -5440 16800 -5270 16800 {
lab=Vdd}
N -5270 16800 -5270 16820 {
lab=Vdd}
N -5400 16850 -5390 16850 {
lab=Vo3+}
N -5320 16850 -5310 16850 {
lab=Vo3-}
N -5590 16800 -5440 16800 {
lab=Vdd}
N -5590 16800 -5590 16820 {
lab=Vdd}
N -5270 16800 -5110 16800 {
lab=Vdd}
N -5110 16800 -5110 16820 {
lab=Vdd}
N -5590 16880 -5590 16900 {
lab=Q3}
N -5110 16880 -5110 16900 {
lab=Q2}
N -5070 16850 -5030 16850 {
lab=Vo2+}
N -5670 16850 -5630 16850 {
lab=Vo2-}
N -5590 16830 -5590 16850 {
lab=Vdd}
N -5440 16830 -5440 16850 {
lab=Vdd}
N -5270 16820 -5270 16840 {
lab=Vdd}
N -5270 16830 -5270 16850 {
lab=Vdd}
N -5110 16810 -5110 16850 {
lab=Vdd}
N -5440 16810 -5440 16850 {
lab=Vdd}
N -5590 16800 -5590 16850 {
lab=Vdd}
N -5270 16880 -5270 16970 {
lab=#net16}
N -5440 17050 -5440 17170 {
lab=Q3}
N -5270 17050 -5270 17160 {
lab=Q2}
N -5270 17160 -5270 17170 {
lab=Q2}
N -5440 16970 -5440 16990 {
lab=#net17}
N -5270 16970 -5270 16990 {
lab=#net16}
N -5400 17020 -5390 17020 {
lab=Q2}
N -5390 17020 -5390 17200 {
lab=Q2}
N -5400 17200 -5390 17200 {
lab=Q2}
N -5320 17020 -5310 17020 {
lab=Q3}
N -5320 17020 -5320 17200 {
lab=Q3}
N -5320 17200 -5310 17200 {
lab=Q3}
N -5440 17060 -5320 17060 {
lab=Q3}
N -5390 17080 -5270 17080 {
lab=Q2}
N -5270 17200 -5190 17200 {
lab=GND}
N -5440 16880 -5440 16970 {
lab=#net17}
N -5440 17340 -5440 17380 {
lab=GND}
N -5440 17380 -5270 17380 {
lab=GND}
N -5270 17330 -5270 17380 {
lab=GND}
N -5110 17340 -5110 17380 {
lab=GND}
N -5270 17380 -5110 17380 {
lab=GND}
N -5110 17260 -5110 17280 {
lab=Q2}
N -5590 17340 -5590 17380 {
lab=GND}
N -5570 17380 -5440 17380 {
lab=GND}
N -5590 17250 -5590 17280 {
lab=Q3}
N -5330 17380 -5330 17410 {
lab=GND}
N -5670 17310 -5630 17310 {
lab=Vo3+}
N -5510 17310 -5480 17310 {
lab=Vo2-}
N -5230 17310 -5200 17310 {
lab=Vo2+}
N -5070 17310 -5040 17310 {
lab=Vo3-}
N -5440 17310 -5270 17310 {
lab=GND}
N -5140 17310 -5110 17310 {
lab=GND}
N -5590 17310 -5560 17310 {
lab=GND}
N -5440 17230 -5440 17280 {
lab=#net18}
N -5270 17230 -5270 17280 {
lab=#net19}
N -5590 16900 -5590 17250 {
lab=Q3}
N -5110 16900 -5110 17250 {
lab=Q2}
N -5110 17250 -5110 17260 {
lab=Q2}
N -5590 17380 -5570 17380 {
lab=GND}
N -5330 16850 -5320 16850 {
lab=Vo3-}
N -5390 16850 -5380 16850 {
lab=Vo3+}
N -5590 17090 -5440 17090 {
lab=Q3}
N -5270 17100 -5110 17100 {
lab=Q2}
N -6120 17460 -6040 17460 {
lab=Vo2+}
N -6100 17700 -6020 17700 {
lab=Vo2-}
N -5980 17720 -5900 17720 {
lab=Vo3-}
N -5500 17020 -5440 17020 {
lab=Vdd}
N -5500 16800 -5500 17020 {
lab=Vdd}
N -5270 17020 -5230 17020 {
lab=Vdd}
N -5230 16800 -5230 17020 {
lab=Vdd}
N -5530 17200 -5440 17200 {
lab=GND}
N -5530 17200 -5530 17380 {
lab=GND}
N -5980 17550 -5980 17570 {
lab=GND}
N -6020 17440 -6020 17520 {
lab=Vo2+}
N -6040 17460 -6020 17460 {
lab=Vo2+}
N -5980 17470 -5980 17490 {
lab=Vo3+}
N -5980 17480 -5860 17480 {
lab=Vo3+}
N -5980 17380 -5980 17410 {
lab=Vdd}
N -5980 17390 -5980 17440 {
lab=Vdd}
N -5980 17520 -5980 17560 {
lab=GND}
N -6020 17680 -6020 17760 {
lab=Vo2-}
N -5980 17710 -5980 17730 {
lab=Vo3-}
N -5980 17800 -5980 17810 {
lab=GND}
N -5980 17790 -5980 17800 {
lab=GND}
N -5980 17760 -5980 17800 {
lab=GND}
N -5980 17630 -5980 17650 {
lab=Vdd}
N -5980 17640 -5980 17680 {
lab=Vdd}
N -5340 15940 -4780 15940 {
lab=Q}
N -4780 15940 -4780 16340 {
lab=Q}
N -4780 16340 -4740 16340 {
lab=Q}
N -5320 17130 -4960 17130 {
lab=Q3}
N -4960 16370 -4960 17130 {
lab=Q3}
N -4960 16370 -4740 16380 {
lab=Q3}
N -4620 16360 -4480 16360 {
lab=#net20}
N -6780 16320 -6780 16360 {
lab=Vc-}
N -6780 16240 -6780 16260 {
lab=Vc+}
N -6780 16290 -6760 16290 {
lab=Vc+}
N -6780 16250 -6760 16250 {
lab=Vc+}
N -6780 16390 -6750 16390 {
lab=Vc-}
N -6780 16350 -6750 16350 {
lab=Vc-}
N -6840 16290 -6820 16290 {
lab=Vc-}
N -6840 16390 -6820 16390 {
lab=gnd}
N -6840 16290 -6840 16330 {
lab=Vc-}
N -6840 16330 -6780 16330 {
lab=Vc-}
N -6840 16390 -6840 16430 {
lab=gnd}
N -6840 16430 -6780 16430 {
lab=gnd}
N -6780 16210 -6780 16240 {
lab=Vc+}
N -6750 16390 -6670 16390 {
lab=Vc-}
N -6760 16290 -6670 16290 {
lab=Vc+}
N -6670 16250 -6670 16290 {
lab=Vc+}
N -6760 16250 -6670 16250 {
lab=Vc+}
N -6670 16350 -6670 16390 {
lab=Vc-}
N -6780 16120 -6780 16150 {
lab=vdd}
N -6840 16180 -6820 16180 {
lab=Vc+}
N -6840 16180 -6840 16230 {
lab=Vc+}
N -6840 16230 -6780 16230 {
lab=Vc+}
N -6780 16180 -6720 16180 {
lab=vdd}
N -6720 16140 -6720 16180 {
lab=vdd}
N -6780 16430 -6780 16450 {
lab=gnd}
N -6720 16110 -6720 16140 {
lab=vdd}
N -6780 16110 -6720 16110 {
lab=vdd}
N -6780 16110 -6780 16120 {
lab=vdd}
N -6780 16420 -6780 16430 {
lab=gnd}
N -6750 16350 -6670 16350 {
lab=Vc-}
N -6850 16990 -6810 16990 {
lab=Vdd}
N -6770 16930 -6770 16960 {
lab=GND}
N -6770 16930 -6720 16930 {
lab=GND}
N -6720 16930 -6720 17050 {
lab=GND}
N -6770 17050 -6720 17050 {
lab=GND}
N -6770 17020 -6770 17050 {
lab=GND}
N -6770 16990 -6720 16990 {
lab=GND}
N -4480 16170 -4480 16360 {
lab=#net20}
N -4480 16170 -4180 16170 {
lab=#net20}
N -4230 16200 -4180 16200 {
lab=reset}
N -4220 16220 -4180 16220 {
lab=scan_en}
N -4220 16240 -4180 16240 {
lab=scan_in}
N -4960 16560 -4230 16560 {
lab=Q3}
N -4230 16270 -4230 16560 {
lab=Q3}
N -4230 16270 -4180 16270 {
lab=Q3}
N -4030 16060 -4030 16080 {
lab=Vdd}
N -4030 16340 -4030 16360 {
lab=GND}
N -4230 16110 -4180 16110 {
lab=clk}
N -4240 16220 -4220 16220 {
lab=scan_en}
N -4240 16200 -4230 16200 {
lab=reset}
N -4640 16560 -4640 16800 {
lab=Q3}
N -4310 16960 -4260 16960 {
lab=reset}
N -4300 16980 -4260 16980 {
lab=scan_en}
N -4300 17000 -4260 17000 {
lab=scan_in}
N -4310 17030 -4260 17030 {
lab=#net54}
N -4110 16820 -4110 16840 {
lab=Vdd}
N -4110 17100 -4110 17120 {
lab=GND}
N -4310 16870 -4260 16870 {
lab=clk}
N -4320 16980 -4300 16980 {
lab=scan_en}
N -4320 16960 -4310 16960 {
lab=reset}
N -4640 16880 -4640 17020 {
lab=#net54}
N -4640 17020 -4640 17030 {
lab=#net54}
N -4640 17030 -4310 17030 {
lab=#net54}
N -4480 16360 -4480 16930 {
lab=#net20}
N -4480 16930 -4260 16930 {
lab=#net20}
N -5000 17800 -5000 17880 {
lab=#net90}
N -4820 17800 -4820 17880 {
lab=Vbcmfb}
N -5000 17720 -5000 17740 {
lab=#net91}
N -4820 17720 -4820 17740 {
lab=#net91}
N -5000 17940 -5000 17960 {
lab=gnd}
N -5000 17960 -4820 17960 {
lab=gnd}
N -4820 17940 -4820 17960 {
lab=gnd}
N -4960 17770 -4860 17770 {
lab=Vdd}
N -5000 17840 -4920 17840 {
lab=#net90}
N -5400 17700 -5400 17730 {
lab=Vdd}
N -5400 17700 -5210 17700 {
lab=Vdd}
N -5210 17700 -5210 17730 {
lab=Vdd}
N -5400 17790 -5400 17870 {
lab=Vcm_det3}
N -5210 17790 -5210 17870 {
lab=Vcm_det3}
N -5460 17760 -5440 17760 {
lab=outr1}
N -5460 17760 -5460 17900 {
lab=outr1}
N -5460 17900 -5440 17900 {
lab=outr1}
N -5170 17760 -5150 17760 {
lab=outr2}
N -5150 17760 -5150 17900 {
lab=outr2}
N -5170 17900 -5150 17900 {
lab=outr2}
N -4600 17730 -4600 17760 {
lab=Vdd}
N -4600 17730 -4410 17730 {
lab=Vdd}
N -4410 17730 -4410 17760 {
lab=Vdd}
N -4600 17820 -4600 17900 {
lab=Vcm3}
N -4410 17820 -4410 17900 {
lab=Vcm3}
N -4600 17960 -4600 17990 {
lab=gnd}
N -4410 17960 -4410 17990 {
lab=gnd}
N -4660 17790 -4640 17790 {
lab=Vc2+}
N -4660 17790 -4660 17930 {
lab=Vc2+}
N -4660 17930 -4640 17930 {
lab=Vc2+}
N -4370 17790 -4350 17790 {
lab=Vc2+}
N -4350 17790 -4350 17930 {
lab=Vc2+}
N -4370 17930 -4350 17930 {
lab=Vc2+}
N -5400 17830 -5210 17830 {
lab=Vcm_det3}
N -4600 17860 -4410 17860 {
lab=Vcm3}
N -5200 17590 -5020 17590 {
lab=Vdd}
N -4600 17990 -4410 17990 {
lab=gnd}
N -5070 18060 -5070 18080 {
lab=gnd}
N -5070 18080 -4770 18080 {
lab=gnd}
N -4770 18050 -4770 18080 {
lab=gnd}
N -5110 18030 -5110 18080 {
lab=gnd}
N -5110 18080 -5070 18080 {
lab=gnd}
N -5070 18000 -5030 18000 {
lab=gnd}
N -5030 18000 -5030 18080 {
lab=gnd}
N -4730 18020 -4730 18080 {
lab=gnd}
N -4770 18080 -4730 18080 {
lab=gnd}
N -4820 17990 -4770 17990 {
lab=gnd}
N -4820 17990 -4820 18080 {
lab=gnd}
N -5240 17570 -5240 17590 {
lab=Vdd}
N -5240 17590 -5180 17590 {
lab=Vdd}
N -5030 17570 -5030 17590 {
lab=Vdd}
N -5200 17540 -5200 17590 {
lab=Vdd}
N -5070 17540 -5070 17590 {
lab=Vdd}
N -5240 17510 -5160 17510 {
lab=Vdd}
N -5160 17510 -5160 17590 {
lab=Vdd}
N -5110 17510 -5030 17510 {
lab=Vdd}
N -5110 17510 -5110 17590 {
lab=Vdd}
N -5400 17930 -5400 17960 {
lab=gnd}
N -5400 17960 -5210 17960 {
lab=gnd}
N -5210 17930 -5210 17960 {
lab=gnd}
N -5240 17540 -5240 17590 {
lab=Vdd}
N -5030 17540 -5030 17580 {
lab=Vdd}
N -5070 18030 -5070 18070 {
lab=gnd}
N -4770 18020 -4770 18060 {
lab=gnd}
N -5400 17760 -5350 17760 {
lab=gnd}
N -5280 17760 -5210 17760 {
lab=gnd}
N -5350 17760 -5280 17760 {
lab=gnd}
N -5400 17900 -5210 17900 {
lab=Vdd}
N -4600 17790 -4410 17790 {
lab=gnd}
N -4600 17930 -4410 17930 {
lab=Vdd}
N -4960 17910 -4860 17910 {
lab=#net90}
N -4820 17910 -4820 17950 {
lab=gnd}
N -5000 17910 -5000 17950 {
lab=gnd}
N -5000 17770 -4960 17770 {
lab=Vdd}
N -4860 17770 -4820 17770 {
lab=Vdd}
N -4920 17840 -4920 17910 {
lab=#net90}
N -5080 17770 -5040 17770 {
lab=Vcm_det3}
N -4780 17770 -4720 17770 {
lab=Vcm3}
N -5000 17720 -4820 17720 {
lab=#net91}
N -4910 17680 -4910 17720 {
lab=#net91}
N -4910 17580 -4910 17620 {
lab=Vdd}
N -5000 17650 -4950 17650 {
lab=Vbiasp}
N -5310 18010 -5310 18030 {
lab=Vdd}
N -5310 18090 -5310 18130 {
lab=Vbiasp}
N -5350 18060 -5350 18110 {
lab=Vbiasp}
N -5350 18110 -5310 18110 {
lab=Vbiasp}
N -5310 18130 -5310 18170 {
lab=Vbiasp}
N -5370 18200 -5350 18200 {
lab=Vbias1}
N -5370 18150 -5370 18200 {
lab=Vbias1}
N -5310 18230 -5310 18250 {
lab=GND}
N -5310 18200 -5310 18240 {
lab=GND}
N -5320 18060 -5310 18060 {
lab=Vdd}
N -5310 18020 -5310 18060 {
lab=Vdd}
N -7920 15830 -7920 15870 {
lab=Vc1-}
N -7920 15750 -7920 15770 {
lab=Vc1+}
N -7920 15800 -7900 15800 {
lab=Vc1+}
N -7920 15760 -7900 15760 {
lab=Vc1+}
N -7920 15900 -7890 15900 {
lab=Vc1-}
N -7920 15860 -7890 15860 {
lab=Vc1-}
N -7980 15800 -7960 15800 {
lab=Vc1-}
N -7980 15900 -7960 15900 {
lab=gnd}
N -7980 15800 -7980 15840 {
lab=Vc1-}
N -7980 15840 -7920 15840 {
lab=Vc1-}
N -7980 15900 -7980 15940 {
lab=gnd}
N -7980 15940 -7920 15940 {
lab=gnd}
N -7920 15720 -7920 15750 {
lab=Vc1+}
N -7890 15900 -7810 15900 {
lab=Vc1-}
N -7900 15800 -7810 15800 {
lab=Vc1+}
N -7810 15760 -7810 15800 {
lab=Vc1+}
N -7900 15760 -7810 15760 {
lab=Vc1+}
N -7810 15860 -7810 15900 {
lab=Vc1-}
N -7920 15630 -7920 15660 {
lab=vdd}
N -7980 15690 -7960 15690 {
lab=Vc1+}
N -7980 15690 -7980 15740 {
lab=Vc1+}
N -7980 15740 -7920 15740 {
lab=Vc1+}
N -7920 15690 -7860 15690 {
lab=vdd}
N -7860 15650 -7860 15690 {
lab=vdd}
N -7920 15940 -7920 15960 {
lab=gnd}
N -7860 15620 -7860 15650 {
lab=vdd}
N -7920 15620 -7860 15620 {
lab=vdd}
N -7920 15620 -7920 15630 {
lab=vdd}
N -7920 15930 -7920 15940 {
lab=gnd}
N -7890 15860 -7810 15860 {
lab=Vc1-}
N -4150 17900 -4150 17940 {
lab=Vc2+}
N -4150 17970 -4120 17970 {
lab=Vc2+}
N -4150 17930 -4120 17930 {
lab=Vc2+}
N -4210 17970 -4190 17970 {
lab=gnd}
N -4210 17970 -4210 18010 {
lab=gnd}
N -4210 18010 -4150 18010 {
lab=gnd}
N -4150 17790 -4150 17820 {
lab=Vc2+}
N -4120 17970 -4040 17970 {
lab=Vc2+}
N -4040 17930 -4040 17970 {
lab=Vc2+}
N -4150 17700 -4150 17730 {
lab=vdd}
N -4210 17760 -4190 17760 {
lab=Vc2+}
N -4210 17760 -4210 17810 {
lab=Vc2+}
N -4210 17810 -4150 17810 {
lab=Vc2+}
N -4150 17760 -4090 17760 {
lab=vdd}
N -4090 17720 -4090 17760 {
lab=vdd}
N -4150 18010 -4150 18030 {
lab=gnd}
N -4090 17690 -4090 17720 {
lab=vdd}
N -4150 17690 -4090 17690 {
lab=vdd}
N -4150 17690 -4150 17700 {
lab=vdd}
N -4150 18000 -4150 18010 {
lab=gnd}
N -4120 17930 -4040 17930 {
lab=Vc2+}
N -4150 17820 -4150 17910 {
lab=Vc2+}
N -4910 18200 -4790 18200 {
lab=Vbcmfb}
N -4950 18120 -4950 18170 {
lab=#net92}
N -4750 18120 -4750 18170 {
lab=#net93}
N -3570 16260 -3570 16290 {
lab=Vdd}
N -3570 16260 -3380 16260 {
lab=Vdd}
N -3380 16260 -3380 16290 {
lab=Vdd}
N -3570 16350 -3570 16430 {
lab=Vcm}
N -3380 16350 -3380 16430 {
lab=Vcm}
N -3570 16490 -3570 16520 {
lab=GND}
N -3570 16520 -3380 16520 {
lab=GND}
N -3380 16490 -3380 16520 {
lab=GND}
N -3630 16320 -3610 16320 {
lab=Vcmref}
N -3630 16320 -3630 16460 {
lab=Vcmref}
N -3630 16460 -3610 16460 {
lab=Vcmref}
N -3340 16320 -3320 16320 {
lab=Vcmref}
N -3320 16320 -3320 16460 {
lab=Vcmref}
N -3340 16460 -3320 16460 {
lab=Vcmref}
N -3570 16390 -3380 16390 {
lab=Vcm}
N -3570 16320 -3380 16320 {
lab=GND}
N -3570 16460 -3370 16460 {
lab=Vdd}
N -3540 16670 -3540 16700 {
lab=Vdd}
N -3540 16670 -3350 16670 {
lab=Vdd}
N -3350 16670 -3350 16700 {
lab=Vdd}
N -3540 16760 -3540 16840 {
lab=Vcm}
N -3350 16760 -3350 16840 {
lab=Vcm}
N -3540 16900 -3540 16930 {
lab=GND}
N -3540 16930 -3350 16930 {
lab=GND}
N -3350 16900 -3350 16930 {
lab=GND}
N -3600 16730 -3580 16730 {
lab=Vcmref}
N -3600 16730 -3600 16870 {
lab=Vcmref}
N -3600 16870 -3580 16870 {
lab=Vcmref}
N -3310 16730 -3290 16730 {
lab=Vcmref}
N -3290 16730 -3290 16870 {
lab=Vcmref}
N -3310 16870 -3290 16870 {
lab=Vcmref}
N -3540 16800 -3350 16800 {
lab=Vcm}
N -3540 16730 -3350 16730 {
lab=GND}
N -3540 16870 -3340 16870 {
lab=Vdd}
N -3880 16110 -3830 16110 {}
N -3880 16150 -3840 16150 {}
N -3880 16170 -3840 16170 {}
N -3880 16190 -3840 16190 {}
N -3880 16210 -3840 16210 {}
N -3880 16230 -3840 16230 {}
N -3880 16250 -3840 16250 {}
N -3880 16270 -3840 16270 {}
N -3880 16290 -3840 16290 {}
N -3960 16910 -3920 16910 {}
N -3960 16930 -3920 16930 {}
N -3960 16950 -3920 16950 {}
N -3960 16970 -3920 16970 {}
N -3960 16990 -3920 16990 {}
N -3960 17010 -3920 17010 {}
N -3960 17030 -3920 17030 {}
N -3960 17050 -3920 17050 {}
N -3960 16870 -3920 16870 {}
N -3210 16710 -3110 16710 {}
N -3210 16290 -3210 16710 {}
N -3210 16280 -3210 16290 {}
N -3210 16280 -3120 16280 {}
N -4950 18200 -4950 18220 {}
N -4750 18200 -4750 18210 {}
N -4750 18210 -4750 18220 {}
C {devices/code.sym} -9500 17450 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {devices/lab_wire.sym} -8630 16460 0 0 {name=p30 sig_type=std_logic lab=Vbias

}
C {sky130_fd_pr/nfet_01v8.sym} -8590 16490 0 0 {name=M26
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8570 16550 0 0 {name=p31 sig_type=std_logic lab=gnd

}
C {sky130_fd_pr/pfet_01v8.sym} -8950 16350 0 1 {name=M27
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8810 16350 0 0 {name=M28
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8990 16250 0 1 {name=M29
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8820 16250 0 0 {name=M30
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8960 16220 0 0 {name=p33 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8860 16220 0 0 {name=p34 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8960 16490 0 0 {name=p35 sig_type=std_logic lab=Vbias

}
C {sky130_fd_pr/nfet_01v8.sym} -8920 16520 0 0 {name=M31
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8900 16580 0 0 {name=p36 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -8900 16460 0 0 {name=p37 sig_type=std_logic lab=Vs

}
C {devices/lab_wire.sym} -8970 16400 0 0 {name=p38 sig_type=std_logic lab=vin1


}
C {devices/lab_wire.sym} -8790 16400 0 0 {name=p39 sig_type=std_logic lab=vin2

}
C {sky130_fd_pr/cap_mim_m3_1.sym} -8900 16320 0 0 {name=C1 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {devices/lab_wire.sym} -9050 15810 0 0 {name=p42 sig_type=std_logic lab=Vcm_det1



}
C {devices/lab_wire.sym} -8270 15840 0 1 {name=p45 sig_type=std_logic lab=Vcm1




}
C {devices/lab_wire.sym} -8510 15890 0 1 {name=p46 sig_type=std_logic lab=Vcm1




}
C {devices/lab_wire.sym} -8810 15890 0 0 {name=p47 sig_type=std_logic lab=Vcm_det1



}
C {devices/lab_wire.sym} -8570 15820 0 0 {name=p48 sig_type=std_logic lab=Vbp




}
C {sky130_fd_pr/pfet_01v8.sym} -9170 15880 0 0 {name=M32
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8940 15880 0 1 {name=M33
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -9170 15740 0 0 {name=M34
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8940 15740 0 1 {name=M35
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8730 15750 0 1 {name=M36
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8590 15750 0 0 {name=M37
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8770 15890 0 0 {name=M38
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8550 15890 0 1 {name=M39
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8680 16000 0 0 {name=M40
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8370 15770 0 0 {name=M41
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8140 15770 0 1 {name=M42
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8370 15910 0 0 {name=M43
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8140 15910 0 1 {name=M44
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8840 16010 0 0 {name=M45
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8500 16000 0 1 {name=M46
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8770 15650 0 1 {name=M47
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8600 15650 0 0 {name=M48
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -9050 15680 0 0 {name=p49 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8740 15620 0 0 {name=p50 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8260 15710 0 0 {name=p51 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -9050 15940 0 0 {name=p52 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8690 16060 0 0 {name=p53 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8260 15970 0 0 {name=p54 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8640 15620 0 0 {name=p55 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -9030 15880 0 0 {name=p56 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -9060 15740 0 0 {name=p57 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8230 15910 0 0 {name=p58 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8250 15770 0 0 {name=p59 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8660 15890 0 0 {name=p60 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8710 16000 0 0 {name=p61 sig_type=std_logic lab=Vbias

}
C {devices/lab_wire.sym} -9210 15820 0 0 {name=p40 sig_type=std_logic lab=vin1

}
C {devices/lab_wire.sym} -8900 15800 0 0 {name=p41 sig_type=std_logic lab=vin2

}
C {devices/lab_wire.sym} -8860 16350 0 0 {name=p62 sig_type=std_logic lab=Vbp




}
C {devices/lab_wire.sym} -7780 16180 0 0 {name=p2 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -8010 16420 0 0 {name=p7 sig_type=std_logic lab=vin1

}
C {devices/lab_wire.sym} -7550 16420 0 0 {name=p8 sig_type=std_logic lab=vin2


}
C {devices/lab_wire.sym} -7950 16350 0 0 {name=p9 sig_type=std_logic lab=vo1

}
C {devices/lab_wire.sym} -7620 16360 0 0 {name=p10 sig_type=std_logic lab=vo2


}
C {devices/lab_wire.sym} -8070 16230 0 0 {name=p20 sig_type=std_logic lab=Vbn




}
C {devices/lab_wire.sym} -7480 16230 0 0 {name=p21 sig_type=std_logic lab=Vbn




}
C {sky130_fd_pr/nfet_01v8.sym} -7970 16420 0 0 {name=M1
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7600 16420 0 1 {name=M2
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7790 16330 1 0 {name=C3 model=cap_mim_m3_1 W=20 L=10 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} -8130 16400 0 0 {name=M4
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7420 16400 0 1 {name=M5
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8350 16870 0 0 {name=p11 sig_type=std_logic lab=vo1

}
C {devices/lab_wire.sym} -8040 16860 0 0 {name=p12 sig_type=std_logic lab=vo2


}
C {devices/lab_wire.sym} -8190 16860 0 0 {name=p13 sig_type=std_logic lab=Vcm_det



}
C {devices/lab_wire.sym} -7550 16880 0 0 {name=p14 sig_type=std_logic lab=Vc1+



}
C {devices/lab_wire.sym} -7240 16890 0 1 {name=p15 sig_type=std_logic lab=Vc1+



}
C {devices/lab_wire.sym} -7410 16890 0 1 {name=p17 sig_type=std_logic lab=Vcm




}
C {devices/lab_wire.sym} -7650 16940 0 1 {name=p16 sig_type=std_logic lab=Vcm




}
C {devices/lab_wire.sym} -7950 16940 0 0 {name=p18 sig_type=std_logic lab=Vcm_det



}
C {devices/lab_wire.sym} -7710 16870 0 0 {name=p19 sig_type=std_logic lab=Vbn




}
C {sky130_fd_pr/pfet_01v8.sym} -8310 16930 0 0 {name=M8
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8080 16930 0 1 {name=M12
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8310 16790 0 0 {name=M10
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8080 16790 0 1 {name=M11
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7870 16800 0 1 {name=M9
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7730 16800 0 0 {name=M13
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7910 16940 0 0 {name=M14
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7690 16940 0 1 {name=M15
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7820 17050 0 0 {name=M16
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7510 16820 0 0 {name=M17
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7280 16820 0 1 {name=M19
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7510 16960 0 0 {name=M20
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7280 16960 0 1 {name=M21
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7980 17060 0 0 {name=M22
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7640 17050 0 1 {name=M23
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7910 16700 0 1 {name=M24
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7740 16700 0 0 {name=M25
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8190 16730 0 0 {name=p3 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -7880 16670 0 0 {name=p4 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -7400 16760 0 0 {name=p5 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8190 16990 0 0 {name=p6 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7830 17110 0 0 {name=p22 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7400 17020 0 0 {name=p23 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7780 16670 0 0 {name=p24 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8170 16930 0 0 {name=p25 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8200 16790 0 0 {name=p26 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7370 16960 0 0 {name=p27 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -7390 16820 0 0 {name=p28 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7800 16940 0 0 {name=p29 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7850 17050 0 0 {name=p63 sig_type=std_logic lab=Vbias1

}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7970 16230 0 0 {name=M18
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7980 16130 0 0 {name=M6
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7600 16230 0 1 {name=M7
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7610 16130 0 1 {name=M49
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_wire.sym} -7800 16420 0 0 {name=p64 sig_type=std_logic lab=gnd

}
C {sky130_fd_pr/nfet_01v8.sym} -7810 16560 0 0 {name=M50
L=0.5
W=6
nf=6 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -7680 16590 0 0 {name=p65 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -7860 16560 0 0 {name=p66 sig_type=std_logic lab=Vbias1

}
C {devices/lab_wire.sym} -8120 16470 0 0 {name=p67 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -7410 16470 0 0 {name=p68 sig_type=std_logic lab=gnd

}
C {sky130_fd_pr/nfet_01v8.sym} -8900 16780 0 0 {name=M3
L=0.15
W=3.36
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8850 16810 0 1 {name=p1 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -8760 16720 0 0 {name=p32 sig_type=std_logic lab=Vdd




}
C {sky130_fd_pr/nfet_01v8.sym} -8740 16780 0 0 {name=M51
L=0.15
W=3.36
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8590 16780 0 0 {name=M52
L=0.15
W=4.2
nf=10
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8450 16780 0 0 {name=M53
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8960 16910 0 1 {name=p69 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -8890 17000 0 0 {name=p70 sig_type=std_logic lab=Vdd




}
C {sky130_fd_pr/pfet_01v8.sym} -9020 16970 0 0 {name=M54
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8860 16970 0 0 {name=M55
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8710 16970 0 0 {name=M56
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8570 16970 0 0 {name=M57
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8430 16970 0 0 {name=M58
L=0.15
W=8.4
nf=20
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -9150 16970 0 0 {name=M59
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8870 17160 0 0 {name=M60
L=0.15
W=1.68
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8820 17190 0 1 {name=p71 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -8840 17100 0 0 {name=p72 sig_type=std_logic lab=Vbias1

}
C {sky130_fd_pr/nfet_01v8.sym} -8560 17190 0 0 {name=M61
L=0.15
W=1.68
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8510 17220 0 1 {name=p73 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -8530 17130 0 0 {name=p74 sig_type=std_logic lab=Vbias1

}
C {sky130_fd_pr/nfet_01v8.sym} -6290 15950 0 0 {name=M62
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6420 15950 0 0 {name=M63
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5920 15950 0 1 {name=M64
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6180 16080 0 0 {name=M65
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6440 15640 0 0 {name=M66
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5920 15640 0 1 {name=M67
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6250 15640 0 1 {name=M68
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6120 15640 0 0 {name=M69
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6250 15820 0 1 {name=M70
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6120 15820 0 0 {name=M71
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6080 15950 0 1 {name=M72
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -6160 16150 0 0 {name=l3 lab=GND}
C {devices/gnd.sym} -6370 15950 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} -6190 15950 0 0 {name=l2 lab=GND}
C {devices/gnd.sym} -5970 15950 0 0 {name=l4 lab=GND}
C {devices/gnd.sym} -6030 15820 0 0 {name=l5 lab=GND}
C {devices/gnd.sym} -6350 15820 0 0 {name=l6 lab=GND}
C {devices/lab_wire.sym} -6170 15590 0 0 {name=p75 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/pfet_01v8.sym} -6200 15900 1 1 {name=M73
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -6200 15840 1 0 {name=p76 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -5870 15950 0 0 {name=p77 sig_type=std_logic lab=Vc+
}
C {devices/lab_wire.sym} -6460 15950 0 0 {name=p78 sig_type=std_logic lab=Vc-
}
C {devices/lab_wire.sym} -6320 15950 0 0 {name=p79 sig_type=std_logic lab=vo1
}
C {devices/lab_wire.sym} -6040 15950 0 0 {name=p80 sig_type=std_logic lab=vo2
}
C {devices/lab_pin.sym} -6235 16080 0 0 {name=p81 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -6155 15920 0 0 {name=p82 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -6495 15640 0 0 {name=p83 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -5865 15640 0 1 {name=p84 sig_type=std_logic lab=clk
}
C {devices/lab_wire.sym} -6270 15750 0 0 {name=p85 sig_type=std_logic lab=Vo+
}
C {devices/lab_wire.sym} -6100 15750 0 0 {name=p86 sig_type=std_logic lab=Vo-
}
C {sky130_fd_pr/pfet_01v8.sym} -5630 15650 0 0 {name=M74
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5110 15650 0 1 {name=M75
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5440 15650 0 1 {name=M76
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5310 15650 0 0 {name=M77
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -5360 15600 0 0 {name=p87 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -5685 15650 0 0 {name=p88 sig_type=std_logic lab=Vo-
}
C {devices/lab_pin.sym} -5055 15650 0 1 {name=p89 sig_type=std_logic lab=Vo+
}
C {sky130_fd_pr/pfet_01v8.sym} -5440 15820 0 1 {name=M78
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5310 15820 0 0 {name=M79
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5440 16000 0 1 {name=M80
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5310 16000 0 0 {name=M81
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -5220 16000 0 0 {name=l13 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} -5480 16110 0 0 {name=M82
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5630 16110 0 0 {name=M83
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5110 16110 0 1 {name=M84
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5270 16110 0 1 {name=M85
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -5580 16110 0 0 {name=l14 lab=GND}
C {devices/gnd.sym} -5380 16110 0 0 {name=l15 lab=GND}
C {devices/gnd.sym} -5160 16110 0 0 {name=l16 lab=GND}
C {devices/lab_wire.sym} -5510 16110 0 0 {name=p90 sig_type=std_logic lab=Vo-
}
C {devices/lab_wire.sym} -5230 16110 0 0 {name=p91 sig_type=std_logic lab=Vo+

}
C {devices/gnd.sym} -5350 16210 0 0 {name=l17 lab=GND}
C {devices/lab_wire.sym} -6100 16260 0 0 {name=p92 sig_type=std_logic lab=Vo+
}
C {devices/lab_wire.sym} -6080 16500 0 0 {name=p93 sig_type=std_logic lab=Vo-
}
C {devices/lab_wire.sym} -5880 16280 0 0 {name=p94 sig_type=std_logic lab=Vo1+
}
C {devices/lab_wire.sym} -5940 16520 0 0 {name=p95 sig_type=std_logic lab=Vo1-
}
C {devices/lab_wire.sym} -5410 15650 0 1 {name=p96 sig_type=std_logic lab=Vo1+
}
C {devices/lab_wire.sym} -5340 15650 0 0 {name=p97 sig_type=std_logic lab=Vo1-
}
C {devices/lab_wire.sym} -5670 16110 0 0 {name=p98 sig_type=std_logic lab=Vo1+
}
C {devices/lab_wire.sym} -5080 16110 0 1 {name=p99 sig_type=std_logic lab=Vo1-
}
C {devices/lab_wire.sym} -5410 15920 0 0 {name=p100 sig_type=std_logic lab=Q1
}
C {devices/lab_wire.sym} -5340 15950 0 0 {name=p101 sig_type=std_logic lab=Q
}
C {devices/gnd.sym} -6000 16370 0 0 {name=l31 lab=GND}
C {devices/lab_wire.sym} -6000 16180 0 0 {name=p102 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/pfet_01v8.sym} -6020 16240 0 0 {name=M86
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6020 16320 0 0 {name=M87
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6020 16480 0 0 {name=M88
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6020 16560 0 0 {name=M89
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -6000 16610 0 0 {name=l7 lab=GND}
C {devices/lab_wire.sym} -6000 16430 0 0 {name=p103 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/nfet_01v8.sym} -6270 17150 0 0 {name=M90
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6400 17150 0 0 {name=M91
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5900 17150 0 1 {name=M92
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6160 17280 0 0 {name=M93
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6420 16840 0 0 {name=M94
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5900 16840 0 1 {name=M95
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6230 16840 0 1 {name=M96
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6100 16840 0 0 {name=M97
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6230 17020 0 1 {name=M98
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6100 17020 0 0 {name=M99
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6060 17150 0 1 {name=M100
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -6140 17350 0 0 {name=l8 lab=GND}
C {devices/gnd.sym} -6350 17150 0 0 {name=l9 lab=GND}
C {devices/gnd.sym} -6170 17150 0 0 {name=l10 lab=GND}
C {devices/gnd.sym} -5950 17150 0 0 {name=l11 lab=GND}
C {devices/gnd.sym} -6010 17020 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} -6330 17020 0 0 {name=l18 lab=GND}
C {devices/lab_wire.sym} -6150 16790 0 0 {name=p104 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/pfet_01v8.sym} -6180 17100 1 1 {name=M101
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -6180 17040 1 0 {name=p105 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -6300 17150 0 0 {name=p106 sig_type=std_logic lab=vo1
}
C {devices/lab_wire.sym} -6020 17150 0 0 {name=p107 sig_type=std_logic lab=vo2
}
C {devices/lab_pin.sym} -6215 17280 0 0 {name=p108 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -6135 17120 0 0 {name=p109 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -6475 16840 0 0 {name=p110 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -5845 16840 0 1 {name=p111 sig_type=std_logic lab=clk
}
C {devices/lab_wire.sym} -6250 16950 0 0 {name=p112 sig_type=std_logic lab=Vo2+
}
C {devices/lab_wire.sym} -6080 16950 0 0 {name=p113 sig_type=std_logic lab=Vo2-
}
C {sky130_fd_pr/pfet_01v8.sym} -5610 16850 0 0 {name=M102
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5090 16850 0 1 {name=M103
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5420 16850 0 1 {name=M104
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5290 16850 0 0 {name=M105
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -5340 16800 0 0 {name=p114 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -5665 16850 0 0 {name=p115 sig_type=std_logic lab=Vo2-
}
C {devices/lab_pin.sym} -5035 16850 0 1 {name=p116 sig_type=std_logic lab=Vo2+
}
C {sky130_fd_pr/pfet_01v8.sym} -5420 17020 0 1 {name=M106
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5290 17020 0 0 {name=M107
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5420 17200 0 1 {name=M108
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5290 17200 0 0 {name=M109
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -5200 17200 0 0 {name=l19 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} -5460 17310 0 0 {name=M110
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5610 17310 0 0 {name=M111
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5090 17310 0 1 {name=M112
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5250 17310 0 1 {name=M113
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
lab=Vo2+}
C {devices/gnd.sym} -5560 17310 0 0 {name=l20 lab=GND}
C {devices/gnd.sym} -5360 17310 0 0 {name=l21 lab=GND}
C {devices/gnd.sym} -5140 17310 0 0 {name=l22 lab=GND}
C {devices/lab_wire.sym} -5490 17310 0 0 {name=p117 sig_type=std_logic lab=Vo2-
}
C {devices/lab_wire.sym} -5210 17310 0 0 {name=p118 sig_type=std_logic lab=Vo2+

}
C {devices/gnd.sym} -5330 17410 0 0 {name=l23 lab=GND}
C {devices/lab_wire.sym} -6080 17460 0 0 {name=p119 sig_type=std_logic lab=Vo2+
}
C {devices/lab_wire.sym} -6060 17700 0 0 {name=p120 sig_type=std_logic lab=Vo2-
}
C {devices/lab_wire.sym} -5860 17480 0 0 {name=p121 sig_type=std_logic lab=Vo3+
}
C {devices/lab_wire.sym} -5920 17720 0 0 {name=p122 sig_type=std_logic lab=Vo3-
}
C {devices/lab_wire.sym} -5390 16850 0 1 {name=p123 sig_type=std_logic lab=Vo3+
}
C {devices/lab_wire.sym} -5320 16850 0 0 {name=p124 sig_type=std_logic lab=Vo3-
}
C {devices/lab_wire.sym} -5650 17310 0 0 {name=p125 sig_type=std_logic lab=Vo3+
}
C {devices/lab_wire.sym} -5060 17310 0 1 {name=p126 sig_type=std_logic lab=Vo3-
}
C {devices/lab_wire.sym} -5390 17120 0 0 {name=p127 sig_type=std_logic lab=Q2
}
C {devices/lab_wire.sym} -5320 17150 0 0 {name=p128 sig_type=std_logic lab=Q3
}
C {devices/gnd.sym} -5980 17570 0 0 {name=l24 lab=GND}
C {devices/lab_wire.sym} -5980 17380 0 0 {name=p129 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/pfet_01v8.sym} -6000 17440 0 0 {name=M114
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6000 17520 0 0 {name=M115
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6000 17680 0 0 {name=M116
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6000 17760 0 0 {name=M117
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -5980 17810 0 0 {name=l25 lab=GND}
C {devices/lab_wire.sym} -5980 17630 0 0 {name=p130 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -5860 17150 0 0 {name=p131 sig_type=std_logic lab=Vc-
}
C {devices/lab_wire.sym} -6450 17150 0 0 {name=p132 sig_type=std_logic lab=Vc+
}
C {sky130_stdcells/xnor2_4.sym} -4680 16360 0 0 {name=x1 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} -6770 16110 1 0 {name=p133 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -6800 16180 0 0 {name=M118
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -6800 16290 0 0 {name=M119
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -6800 16390 0 0 {name=M120
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} -6780 16450 2 0 {name=p134 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} -6710 16350 0 0 {name=p135 sig_type=std_logic lab=Vc-
}
C {devices/lab_wire.sym} -6720 16250 0 0 {name=p136 sig_type=std_logic lab=Vc+
}
C {sky130_fd_pr/nfet_01v8.sym} -6790 16990 0 0 {name=M121
L=0.15
W=20.16
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -6830 16990 0 0 {name=p137 sig_type=std_logic lab=Vdd
}
C {devices/gnd.sym} -6730 17050 0 0 {name=l26 lab=GND}
C {/home/ganga/Desktop/xschemfiles/scanchain.sym} -4020 16000 0 0 {name=x2}
C {devices/gnd.sym} -4030 16350 0 0 {name=l27 lab=GND}
C {devices/lab_wire.sym} -4030 16060 0 0 {name=p138 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -4240 16200 2 1 {name=p139 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} -4240 16220 2 1 {name=p140 sig_type=std_logic lab=scan_en
}
C {devices/lab_pin.sym} -4220 16240 2 1 {name=p141 sig_type=std_logic lab=scan_in
}
C {devices/lab_pin.sym} -4200 16110 2 1 {name=p142 sig_type=std_logic lab=clk
}
C {devices/code_shown.sym} -7565 17560 0 0 {name=s1 only_toplevel=false value="
.include /home/ganga/Desktop/charge_pumps/scanchain.spice
.include /home/ganga/sky_pdk/sky130/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
"}
C {sky130_stdcells/inv_1.sym} -4640 16840 3 1 {name=x48 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/ganga/Desktop/xschemfiles/scanchain.sym} -4100 16760 0 0 {name=x49}
C {devices/gnd.sym} -4110 17110 0 0 {name=l28 lab=GND}
C {devices/lab_wire.sym} -4110 16820 0 0 {name=p226 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -4320 16960 2 1 {name=p289 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} -4320 16980 2 1 {name=p298 sig_type=std_logic lab=scan_en
}
C {devices/lab_pin.sym} -4300 17000 2 1 {name=p360 sig_type=std_logic lab=scan_in
}
C {devices/lab_pin.sym} -4280 16870 2 1 {name=p362 sig_type=std_logic lab=clk
}
C {devices/lab_wire.sym} -5460 17840 0 0 {name=p594 sig_type=std_logic lab=outr1

}
C {devices/lab_wire.sym} -5150 17830 0 0 {name=p595 sig_type=std_logic lab=outr2


}
C {devices/lab_wire.sym} -5300 17830 0 0 {name=p596 sig_type=std_logic lab=Vcm_det3



}
C {devices/lab_wire.sym} -4520 17860 0 1 {name=p599 sig_type=std_logic lab=Vcm3




}
C {devices/lab_wire.sym} -4750 17770 0 1 {name=p600 sig_type=std_logic lab=Vcm3




}
C {devices/lab_wire.sym} -4820 17840 0 0 {name=p601 sig_type=std_logic lab=Vbcmfb




}
C {sky130_fd_pr/pfet_01v8.sym} -5420 17900 0 0 {name=M122
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5190 17900 0 1 {name=M123
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5420 17760 0 0 {name=M124
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5190 17760 0 1 {name=M125
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5020 17770 0 0 {name=M126
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4800 17770 0 1 {name=M127
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4980 17910 0 1 {name=M128
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4840 17910 0 0 {name=M129
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4620 17790 0 0 {name=M130
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4390 17790 0 1 {name=M131
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4620 17930 0 0 {name=M132
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4390 17930 0 1 {name=M133
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/code.sym} -5660 17720 0 0 {name=TT_MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {sky130_fd_pr/nfet_01v8.sym} -5090 18030 0 0 {name=M134
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4750 18020 0 1 {name=M135
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5220 17540 0 1 {name=M136
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5050 17540 0 0 {name=M137
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -5300 17700 0 0 {name=p602 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -5190 17510 0 0 {name=p603 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -4510 17730 0 0 {name=p604 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -5300 17960 0 0 {name=p605 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -4940 18080 0 0 {name=p606 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -4510 17990 0 0 {name=p607 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -5090 17510 0 0 {name=p608 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -5280 17900 0 0 {name=p609 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -5310 17760 0 0 {name=p610 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -4480 17930 0 0 {name=p611 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -4500 17790 0 0 {name=p612 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -4920 17960 0 0 {name=p613 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -4910 17770 0 0 {name=p614 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -5060 17770 0 0 {name=p615 sig_type=std_logic lab=Vcm_det3



}
C {devices/lab_wire.sym} -5130 17590 0 0 {name=p616 sig_type=std_logic lab=Vdd




}
C {sky130_fd_pr/pfet_01v8.sym} -4930 17650 0 0 {name=M138
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -4910 17600 0 0 {name=p617 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -5000 17650 0 1 {name=p618 sig_type=std_logic lab=Vbiasp





}
C {sky130_fd_pr/pfet_01v8.sym} -5330 18060 0 0 {name=M139
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -5310 18010 0 0 {name=p619 sig_type=std_logic lab=Vdd
}
C {devices/gnd.sym} -5310 18250 0 0 {name=l29 lab=GND}
C {devices/lab_wire.sym} -5370 18170 0 0 {name=p620 sig_type=std_logic lab=Vbias1

}
C {sky130_fd_pr/nfet_01v8.sym} -5330 18200 0 0 {name=M140
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -5350 18090 0 0 {name=p621 sig_type=std_logic lab=Vbiasp

}
C {devices/lab_pin.sym} -7910 15620 1 0 {name=p622 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7940 15690 0 0 {name=M141
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7940 15800 0 0 {name=M142
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7940 15900 0 0 {name=M143
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} -7920 15960 2 0 {name=p623 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} -7850 15860 0 0 {name=p624 sig_type=std_logic lab=Vc1-
}
C {devices/lab_wire.sym} -7860 15760 0 0 {name=p625 sig_type=std_logic lab=Vc1+
}
C {devices/lab_wire.sym} -8410 15840 0 0 {name=p43 sig_type=std_logic lab=Vc1+
}
C {devices/lab_wire.sym} -8100 15850 0 0 {name=p44 sig_type=std_logic lab=Vc1+
}
C {devices/lab_pin.sym} -4140 17690 1 0 {name=p626 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -4170 17760 0 0 {name=M144
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -4170 17970 0 0 {name=M146
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} -4150 18030 2 0 {name=p627 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} -4080 17930 0 0 {name=p628 sig_type=std_logic lab=Vc2+
}
C {devices/lab_wire.sym} -4660 17870 0 0 {name=p597 sig_type=std_logic lab=Vc2+
}
C {devices/lab_wire.sym} -4350 17860 0 0 {name=p598 sig_type=std_logic lab=Vc2+
}
C {sky130_fd_pr/nfet_01v8.sym} -4770 18200 0 0 {name=M145
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4930 18200 0 1 {name=M147
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -4950 18230 0 0 {name=l30 lab=GND}
C {devices/gnd.sym} -4750 18230 0 0 {name=l32 lab=GND}
C {devices/lab_wire.sym} -4830 18200 0 0 {name=p629 sig_type=std_logic lab=Vbcmfb




}
C {devices/lab_wire.sym} -4950 18130 0 0 {name=p671 sig_type=std_logic lab=outr1

}
C {devices/lab_wire.sym} -4750 18130 0 0 {name=p672 sig_type=std_logic lab=outr2


}
C {devices/gnd.sym} -3470 16520 0 0 {name=l33 lab=GND}
C {devices/lab_wire.sym} -3470 16260 0 0 {name=p143 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -3630 16380 0 0 {name=p144 sig_type=std_logic lab=vo1



}
C {devices/lab_wire.sym} -3320 16390 0 1 {name=p145 sig_type=std_logic lab=vo1



}
C {devices/lab_wire.sym} -3490 16390 0 1 {name=p146 sig_type=std_logic lab=Vcp1




}
C {sky130_fd_pr/nfet_01v8.sym} -3590 16320 0 0 {name=M148
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -3360 16320 0 1 {name=M149
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3480 16320 0 0 {name=l34 lab=GND}
C {devices/lab_wire.sym} -3470 16460 0 0 {name=p147 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} -3590 16460 0 0 {name=M150
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} -3360 16460 0 1 {name=M151
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/gnd.sym} -3440 16930 0 0 {name=l35 lab=GND}
C {devices/lab_wire.sym} -3440 16670 0 0 {name=p148 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -3600 16790 0 0 {name=p149 sig_type=std_logic lab=vo2



}
C {devices/lab_wire.sym} -3290 16800 0 1 {name=p150 sig_type=std_logic lab=vo2



}
C {devices/lab_wire.sym} -3460 16800 0 1 {name=p151 sig_type=std_logic lab=Vcp2




}
C {sky130_fd_pr/nfet_01v8.sym} -3560 16730 0 0 {name=M152
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -3330 16730 0 1 {name=M153
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3450 16730 0 0 {name=l36 lab=GND}
C {devices/lab_wire.sym} -3440 16870 0 0 {name=p152 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} -3560 16870 0 0 {name=M154
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} -3330 16870 0 1 {name=M155
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {reconfigurable_CP.sym} -2970 16370 0 0 {name=x3}
C {reconfigurable_CP.sym} -2960 16800 0 0 {name=x4}
C {devices/lab_wire.sym} -3830 16110 0 1 {name=p153 sig_type=std_logic lab=scn_out



}
C {devices/lab_wire.sym} -3840 16150 0 1 {name=p154 sig_type=std_logic lab=o1


}
C {devices/lab_wire.sym} -3840 16170 0 1 {name=p155 sig_type=std_logic lab=o2


}
C {devices/lab_wire.sym} -3840 16190 0 1 {name=p156 sig_type=std_logic lab=o3


}
C {devices/lab_wire.sym} -3840 16210 0 1 {name=p157 sig_type=std_logic lab=o4


}
C {devices/lab_wire.sym} -3840 16230 0 1 {name=p158 sig_type=std_logic lab=o5


}
C {devices/lab_wire.sym} -3840 16250 0 1 {name=p159 sig_type=std_logic lab=o6


}
C {devices/lab_wire.sym} -3840 16270 0 1 {name=p160 sig_type=std_logic lab=o7


}
C {devices/lab_wire.sym} -3840 16290 0 1 {name=p161 sig_type=std_logic lab=o8


}
C {devices/lab_wire.sym} -3920 16910 0 1 {name=p162 sig_type=std_logic lab=ob1


}
C {devices/lab_wire.sym} -3920 16930 0 1 {name=p163 sig_type=std_logic lab=ob2

}
C {devices/lab_wire.sym} -3920 16950 0 1 {name=p164 sig_type=std_logic lab=ob3


}
C {devices/lab_wire.sym} -3920 16970 0 1 {name=p165 sig_type=std_logic lab=ob4


}
C {devices/lab_wire.sym} -3920 16990 0 1 {name=p166 sig_type=std_logic lab=ob5


}
C {devices/lab_wire.sym} -3920 17010 0 1 {name=p167 sig_type=std_logic lab=ob6


}
C {devices/lab_wire.sym} -3920 17030 0 1 {name=p168 sig_type=std_logic lab=ob7}
C {devices/lab_wire.sym} -3920 17050 0 1 {name=p169 sig_type=std_logic lab=ob8


}
C {devices/lab_wire.sym} -3920 16870 0 1 {name=p170 sig_type=std_logic lab=scn_out


}
C {devices/lab_wire.sym} -3120 16320 0 0 {name=p171 sig_type=std_logic lab=o1


}
C {devices/lab_wire.sym} -3120 16340 0 0 {name=p172 sig_type=std_logic lab=o2


}
C {devices/lab_wire.sym} -3120 16360 0 0 {name=p173 sig_type=std_logic lab=o3


}
C {devices/lab_wire.sym} -3120 16380 0 0 {name=p174 sig_type=std_logic lab=o4


}
C {devices/lab_wire.sym} -3120 16400 0 0 {name=p175 sig_type=std_logic lab=o5


}
C {devices/lab_wire.sym} -3120 16420 0 0 {name=p176 sig_type=std_logic lab=o6


}
C {devices/lab_wire.sym} -3120 16440 0 0 {name=p177 sig_type=std_logic lab=o7


}
C {devices/lab_wire.sym} -3120 16460 0 0 {name=p178 sig_type=std_logic lab=o8


}
C {devices/lab_wire.sym} -3120 16300 0 0 {name=p179 sig_type=std_logic lab=Vcp1




}
C {devices/lab_wire.sym} -3110 16730 0 0 {name=p180 sig_type=std_logic lab=Vcp2




}
C {devices/lab_wire.sym} -3110 16750 0 0 {name=p181 sig_type=std_logic lab=ob1


}
C {devices/lab_wire.sym} -3110 16770 0 0 {name=p182 sig_type=std_logic lab=ob2

}
C {devices/lab_wire.sym} -3110 16790 0 0 {name=p183 sig_type=std_logic lab=ob3


}
C {devices/lab_wire.sym} -3110 16810 0 0 {name=p184 sig_type=std_logic lab=ob4


}
C {devices/lab_wire.sym} -3110 16830 0 0 {name=p185 sig_type=std_logic lab=ob5


}
C {devices/lab_wire.sym} -3110 16850 0 0 {name=p186 sig_type=std_logic lab=ob6


}
C {devices/lab_wire.sym} -3110 16870 0 0 {name=p187 sig_type=std_logic lab=ob7}
C {devices/lab_wire.sym} -3110 16890 0 0 {name=p188 sig_type=std_logic lab=ob8


}
C {devices/lab_wire.sym} -3210 16470 0 0 {name=p189 sig_type=std_logic lab=clk_in




}
